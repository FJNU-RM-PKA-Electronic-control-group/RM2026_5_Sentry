# Keil uVision project Hero.uvprojx, settings and files
target 5_Sentry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Hero +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/SEGGER/Config;../Middlewares/Third_Party/SEGGER/RTT;../User/App/ins_task;../User/App/led_flow_task;../User/App/test_task;../User/App/typedef;../User/App/usart_task;../User/Bsp/delay;../User/Bsp/dwt;../User/Bsp/led;../User/Bsp/pwm;../User/Bsp/spi;../User/Bsp/usart;../User/Bsp/can;../User/Bsp/log;../User/Modules/algorithm;../User/Modules/arm_math;../User/Modules/bmi088;../User/Modules/ist8310;../User/Modules/motor;../User/Modules/daemon;../User/Modules/remote;../User/Modules/message_center;../User/Modules/motor/dji_motor;../User/App/robot;../User/App/robot_cmd;../User/App/chassis;../User/App/gimbal;../User/App/shoot;../User/Modules/motor/dm_motor;../User/Modules/motor/rmd_motor;../User/App/motor_task;../User/Modules/feed_forward;../User/Bsp/flash;../User/Modules/calibration;../User/Bsp/iic;../User/Bsp/gpio;../User/App/vision;../User/App/calibrate;../User/Modules/buzzer;../User/Modules/can_comm;../User/App/cmd_send;../User/Modules/referee
  asm include: ..\\Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/SEGGER_RTT
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Bsp
    ../User/Bsp/delay/: bsp_delay.c
    ../User/Bsp/dwt/: bsp_dwt.c
    ../User/Bsp/led/: bsp_led.c
    ../User/Bsp/pwm/: bsp_imu_pwm.c bsp_pwm.c
    ../User/Bsp/spi/: bsp_spi.c
    ../User/Bsp/usart/: bsp_usart1.c bsp_usart.c
    ../User/Bsp/can/: bsp_can.c
    ../User/Bsp/log/: bsp_log.c
    ../User/Bsp/flash/: bsp_flash.c
    ../User/Bsp/iic/: bsp_iic.c
    ../User/Bsp/gpio/: bsp_gpio.c
  group Modules
    ../User/Modules/arm_math/: arm_cortexM4lf_math.lib
    ../User/Modules/bmi088/: BMI088driver.c BMI088Middleware.c
    ../User/Modules/algorithm/: kalman_filter.c QuaternionEKF.c controller.c user_lib.c pid.c MahonyAHRS.c crc8.c
    ../User/Modules/daemon/: daemon.c
    ../User/Modules/remote/: remote_control.c
    ../User/Modules/message_center/: message_center.c
    ../User/Modules/motor/dji_motor/: dji_motor.c
    ../User/Modules/motor/dm_motor/: dm_motor.c
    ../User/Modules/motor/rmd_motor/: rmd_motor.c
    ../User/Modules/feed_forward/: feed_forward.c
    ../User/Modules/calibration/: calibration.c
    ../User/Modules/ist8310/: ist8310driver.c ist8310driver_middleware.c
    ../User/Modules/buzzer/: buzzer.c
    ../User/Modules/can_comm/: can_comm.c
    ../User/Modules/referee/: crc_ref.c gimbal_referee.c referee_UI.c rm_referee.c referee_task.c
  group App
    ../User/App/robot/: robot_def.h robot_task.h robot.c
    ../User/App/robot_cmd/: robot_cmd.c
    ../User/App/gimbal/: gimbal.c
    ../User/App/chassis/: chassis.c
    ../User/App/shoot/: shoot.c
    ../User/App/cmd_send/: cmd_send.c
    ../User/App/motor_task/: motor_task.c
    ../User/App/ins_task/: INS_task.c
    ../User/App/usart_task/: usart_task.c
    ../User/App/test_task/: test_task.c
    ../User/App/led_flow_task/: led_flow_task.c
    ../User/App/vision/: vision.c
    ../User/App/calibrate/: calibrate.c
software components: CMSIS:CORE 4.3.0
